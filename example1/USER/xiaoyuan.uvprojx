# Keil uVision project xiaoyuan.uvprojx, settings and files
target example (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xiaoyuan +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Listings\app.bin .\Objects\xiaoyuan.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F407
  c include: ..\FWLIB\Include;..\USER;..\CORE;..\HARDWARE;..\HARDWARE\bsp\bsp_inc;..\HARDWARE\module\md_inc;..\FreeRTOS\include;..\FreeRTOS\portable;..\LWIP\arch;..\LWIP\port;..\LWIP\include\lwip;..\LWIP\include\lwip\apps;..\LWIP\include\lwip\priv;..\LWIP\include\lwip\prot;..\LWIP\include;..\LWIP;..\LWIP\include\compat;..\LWIP\include\compat\posix;..\LWIP\include\compat\posix\arpa;..\LWIP\include\compat\posix\net;..\LWIP\include\compat\posix\sys;..\LWIP\include\compat\stdc;..\LWIP\include\netif;..\LWIP\include\netif\ppp;..\LWIP\include\netif\ppp\polarssl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_gd32f407.s
  group USR
    ./: gd32f4xx_it.c main.c system_gd32f4xx.c
  group FWLIB
    ../FWLIB/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group HARDWARE/bsp
    ../HARDWARE/bsp/bsp_src/: bsp_can.c bsp_iwdg.c bsp_sys.c bsp_systick.c bsp_time.c bsp_uart.c bsp_gpio.c bsp_flash.c bsp_enet.c
  group HARDWARE/module
    ../HARDWARE/module/md_src/: md_log.c md_lwip.c md_app.c
  group FreeRTOS/src
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Lwip/api
    ../LWIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/port
    ../LWIP/port/: ethernetif.c sys_arch.c
  group Lwip/core
    ../LWIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LWIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip/netif
    ../LWIP/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
